# IAR project FreeRTOS.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: MSP430F5172 MSP430F5172
  General.GStackSize2: 128
  General.GHeapSize2: 128
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; F5XX_6XX_Core_Lib; MSP_HAL; FreeRTOS_Source; FreeRTOS_Source\Include; FreeRTOS_Source\Portable; FreeRTOS_Source\Portable\Include
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: __DATA_MODEL_LARGE__
  A430.AUserIncludes: as above
  XLINK.XclFile: C:\Users\cesinha\Downloads\Mestrado\FreeRTOS_Multiport\FreeRTOS_IAR5_multiMSP430_KDS_KL25Z\lnk430f5172_FreeRTOS.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: FreeRTOSConfig.h lnk430f5172_FreeRTOS.xcl low_level_init.c main.c RunTimeStatsConfig.c
  group F5XX_6XX_Core_Lib
    F5XX_6XX_Core_Lib/: hal_board.c hal_PMM.c hal_UCS.c
  group F5XX_6XX_Core_Lib/Include
    F5XX_6XX_Core_Lib/: hal_board.h HAL_MACROS.h hal_PMM.h hal_UCS.h
  group F5XX_6XX_Core_Lib/MSP_HAL
    MSP_HAL/: hal_MSP-EXP430F5438.h
  group FreeRTOS_Source
    FreeRTOS_Source/: list.c tasks.c
  group FreeRTOS_Source/Include
    FreeRTOS_Source/Include/: deprecated_definitions.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h StackMacros.h stdint.h task.h
  group FreeRTOS_Source/Portable
    FreeRTOS_Source/Portable/: heap_1.c port.c portext.s43
  group FreeRTOS_Source/Portable/Include
    FreeRTOS_Source/Portable/Include/: data_model.h portmacro.h
    FreeRTOS_Source/Portable/: portasm.h
